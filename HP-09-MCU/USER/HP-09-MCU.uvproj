# Keil uVision project HP-09-MCU.uvproj, settings and files
target HP-09 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: HP-09-MCU +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\LIB\includes;..\LIB\Library\Includes;..\HARDWARE\key;..\HARDWARE\LED;..\HARDWARE\Timer
  group USER
    ./: Main.c
  group HARD
    ./: conturol_user.c
    ../HARDWARE/Timer/: timer.c
    ../HARDWARE/key/: key.c
    ../LIB/Library/Sources/: wdt.c
  group LIB
    ../LIB/Library/Sources/: pwm.c system_clock.c
  group DOC
    ../: Readme.txt
