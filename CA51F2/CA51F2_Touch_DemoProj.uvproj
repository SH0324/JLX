# Keil uVision project CA51F2_Touch_DemoProj.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51fx +hex
  c flags: Optimize=8
  c include: .\includes;.\Library\Includes;.\Library\Lib;.\TS_Lib\Includes;.\USER
  link misc: REMOVEUNUSED
  group Sources
    ./USER/: main.c interrupt.c conturol_user.c Key.c music.c led.c
    ./Library/Sources/: system_clock.c stop_idle.c pwm.c delay.c rtc.c uart.c lcd.c wdt.c
  group TS_lib
    ./TS_Lib/Sources/: debug.c ts_api.c ts_service.LIB
    ./USER/: readme.txt
